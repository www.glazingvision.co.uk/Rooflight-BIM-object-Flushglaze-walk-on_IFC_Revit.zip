Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2017-01-25T15:45:47
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140223_1515(x64) - Exporter 15.7.0.0 - Alternate UI 15.7.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Wed Jan 25 15:45:47 2017* Host: NCL-PI08* Database: C:\Users\KovacsG\AppData\Local\Temp\{59C1FA15-C39F-44FD-9C8A-CC37C328CF80}\ifc* Database version: 5507* Database creation date: Wed Jan 25 15:45:46 2017* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Wed Jan 25 15:45:47 2017* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Wed Jan 25 15:45:47 2017* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: X:\NBL\Manufacturer\G\Glazing Vision_12688\NBLA0680\Authoring\IFC\NBS_GlazingVisionLtd_FrmdRflghts_FlushglazeInternal.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcWindow: WalkOn-1200x1200mm_25.5mm, NBS_GlazingVisionLtd_FrmdRflghts_FlushglazeInternal:WalkOn-1200x1200mm_25.5mm:186403
In: Level 1
Type - ConstructionType: OTHER_CONSTRUCTION; OperationType: SINGLE_PANEL; ParameterTakesPrecedence: no; Sizeable: no; Classification: Pr_30_59_72_31 (Uniclass2015); Material: NBS_Concept, NBS_Glass_Double
Type - NBS_General - Author: NBS; BIMObjectName: NBS_GlazingVisionLtd_FramedRooflights_FlushglazeInternal_WalkOn; ManufacturerName: Glazing Vision Ltd; ManufacturerURL: www.glazingvision.co.uk; NBSCertification: www.nationalbimlibrary.com/cert/zkjelggu; NBSDescription: Framed rooflights; NBSNote: n/a; NBSOfficeMasterTag: n/a; NBSReference: 45-25-99/410; NBSTypeID: n/a; ProductInformation: www.glazingvision.co.uk/wp-content/uploads/2014/02/GV-Standard-Flushglaze-Internal-Walk-On-Product-Data-Sheet-Ver-1.0.pdf; Revision: n/a; Uniclass2015Code: Pr_30_59_72_31; Uniclass2015Title: Framed rooflights; Uniclass2015Version: Products v1.3; Version: 1
Type - NBS_Data - Accessories: n/a; CavityType: n/a; Certification: BBA Certificate; DesignLoads: 1.5 kN/m² (Uniform), 2.0 kN (Concentrated); Form: Flat square or rectangular; FrameFinishCoating: Qualicoat approved polyester powder coating; FrameFinishColour: RAL7015 Slate Grey; FrameFinishTexture: n/a; FrameMaterial: Aluminium; GlazingOptions: n/a; GlazingOrInfillCoating: n/a; GlazingOrInfillConstruction: Single glazed; GlazingOrInfillType: Laminated glass pane; InnerPaneType: n/a; IntermediatePaneType: n/a; LightTransmission: 0.851; MaximumArea: 3 m²; MaximumSize: 4000 mm; MinimumSize: 400 mm; OperationControl: n/a; OperationType: Fixed; OuterPaneType: 25.5 mm heat soak tested toughened laminated; PitchAngleRange: n/a; RooflightWeight: 104 kg; Seals: Structural glazing tape, polyurethane adhesive and silicone; ShadingCoefficient: 0.79; StructuralKerb: n/a; ThermalBreak: no; WholeWindowUValue: 1.3 W/m²K Uw
Type - Pset_WindowCommon - AcousticRating: 38 dB; FireRating: n/a; GlazingAreaFraction: 0; Infiltration: 0; IsExternal: no; Reference: n/a; SecurityRating: n/a; SmokeStop: no; ThermalTransmittance: 0
Type - Pset_DoorWindowGlazingType - BeamRadiationTransmittance: 0; FillGas: n/a; GlassColor: Clear; GlassLayers: 1; GlassThickness1: 25.5 mm; GlassThickness2: 0 mm; GlassThickness3: 0 mm; IsCoated: no; IsLaminated: yes; IsTempered: yes; IsWired: no; Reflectivity: 0.083; SolarHeatGainTransmittance: 0; ThermalTransmittanceSummer: 0; ThermalTransmittanceWinter: 0; Translucency: 0
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_30_59_72_31: Framed rooflights; CodePerformance: n/a; Color: Grey frame, clear glass; Constituents: Aluminium frame, glass pane; Description: Walk-on internal horizontal light designed to provide maximum daylight with minimal internal structure; DurationUnit: year; ExpectedLife: n/a; Features: Walk on glazing, increases daylight throughout the building, flush finish, low profile simple installation, minimal exposed framework; Finish: n/a; Grade: n/a; Manufacturer: sales@glazingvision.co.uk; Material: Aluminium, glass; ModelNumber: 402; ModelReference: GV Flushglaze Walk On Internal Horizontal Light; Name: FramedRooflights_FlushglazeInternal_WalkOn_GlazingVisionLtd; NominalHeight: 0 mm; NominalLength: 1200 mm; NominalWidth: 1200 mm; ReplacementCost: n/a; Shape: Rectangular; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: Manufacturer's warranty; WarrantyDurationLabor: n/a; WarrantyDurationParts: 2 (installed by others) or 10 years (installed by Glazing Vision); WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: customerservices@glazingvision.co.uk
OverallHeight: 306.4 mm; OverallWidth: 1301.8 mm
NBS_Data - ComponentNumber: n/a; WindowNumber: n/a
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
